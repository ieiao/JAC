# Repository ieiao/JAC

File README.md:

# Just A Clock

## How to compile

1. goto source directory

```
$ cd fw
```

2. compress web source file

```
$ cd spiffs_image
$ gzip -9 *
$ cd ..
```

3. build project

```
$ idf.py build
```

4. generate resources

```
$ # output is build/res/res.bin
$ ./tools/genres.sh
```

5. generate OTA file (optional)

```
$ # output is build/JAC_ota.bin
$ ./tools/genota.sh
```

6. flash

```
$ # resources and web archives must flash with app
$ python -m esptool --chip esp32c3 -b 460800 --before default_reset --after hard_reset write_flash --flash_mode dio --flash_size 4MB --flash_freq 80m 0x0 build/bootloader/bootloader.bin 0x8000 build/partition_table/partition-table.bin 0xd000 build/ota_data_initial.bin 0x90000 build/JAC.bin 0x380000 build/storage.bin 0x10000 build/res/res.bin
```

You can use the file generated in __step 5__ to update the firmware through OTA.

## KiCad design hw/JAC.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric
C2: 1uF; C_0603_1608Metric
C3: 0.1uF; C_0603_1608Metric
C4: 10uF; C_0805_2012Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
JP1, JP2, JP3, JP4: Jumper_2_Open; R_0402_1005Metric
Q1: AO3401A; SOT-23
R1, R2, R3, R4, R9: 10K; R_0603_1608Metric
R5, R6: 5.1K; R_0603_1608Metric
R7, R8: 4.7K; R_0603_1608Metric
SW1: BT0; SW_Push_SPST_NO_Alps_SKRK
U1: EPDM
U2: 4056M
U3: RX-8025T; SO-14_5.3x10.2mm_P1.27mm
U4: ESP32-C3-WROOM-02

Connections:
+3V3: C3.1, C4.1, Q1.2 (S), R1.1, R2.1, R3.2, R4.1, R7.1, R8.1, R9.1, U2.3 (3V3), U2.7 (PS), U3.6 (VDD), U4.1 (3V3)
/ALRT: U2.6 (ALRT), U4.15 (IO3)
/CHIP_PU: C2.2, JP4.2 (B), R1.2, U4.2 (EN)
/CHRG: R4.2, U2.9 (CHRG), U4.17 (IO1)
/EPD_BUSY: U1.4 (BUSY), U4.4 (IO5)
/EPD_DC: JP2.2 (B), U1.6 (DC), U4.8 (IO9)
/EPD_PC: Q1.1 (G), R2.2, R9.2, U4.7 (IO8)
/EPD_RST: U1.5 (RST), U4.3 (IO4)
/FSPICLK: U1.8 (CLK), U4.5 (IO6)
/FSPICS0: U1.7 (CS), U4.10 (IO10)
/FSPID: U1.9 (DIN), U4.6 (IO7)
/I2C_SCL: R7.2, U2.5 (SCL), U3.2 (SCL), U4.14 (IO19)
/I2C_SDA: R8.2, U2.4 (SDA), U3.13 (SDA), U4.13 (IO18)
/IO0: C1.2, SW1.2, U4.18 (IO0)
/IO2: R3.1, U3.10 (INT), U4.16 (IO2)
/RXD: JP3.2 (B), U4.11 (RXD)
/TXD: JP1.2 (B), U4.12 (TXD)
GND: C1.1, C2.1, C3.2, C4.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R5.2, R6.2, SW1.1, U1.1 (GND), U1.10 (MP), U2.2 (GND), U3.7 (FOE), U3.11 (GND), U4.9 (GND), U4.19 (EPAD)
unnamed: J1.A5 (CC1), R5.1
unnamed: J1.A6 (D+), JP3.1 (A)
unnamed: J1.A7 (D-), JP1.1 (A)
unnamed: J1.B5 (CC2), R6.1
unnamed: J1.B6 (D+), JP4.1 (A)
unnamed: J1.B7 (D-), JP2.1 (A)
unnamed: Q1.3 (D), U1.2 (3V3)
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.1 (VBUS)

Notes on the sheet:
墨水屏电源控制
IO2/IO8按照数据手册Download Boot 模式要求保持上拉状态
SPI CLK
SPI MISO/RTC中断输入
EPD BUSY
SPI CS
USB转串口侧引脚顺序 A6 TXD A7 RXD B6 EN B7 IO0
电源模块ALRT信号
EPD RST
EPD DC & STRAP
充电状态检测
IO0用作输入按键，用来唤醒系统
I2C SCL
SPI MOSI
I2C SDA
用户按键

Board: 2 copper layers, 58.9 x 22.0 mm, 23 parts (11 on the bottom side), 26 nets.

## Code that names these connections

File fw/components/compat/io_compat.h:

#ifndef __IO_COMPAT_H__
#define __IO_COMPAT_H__

#include "driver/gpio.h"

#define CS_GPIO         GPIO_NUM_10
#define SCLK_GPIO       GPIO_NUM_6
#define SDIN_GPIO       GPIO_NUM_7
#define BUSY_GPIO       GPIO_NUM_19
#define DC_GPIO         GPIO_NUM_9
#define RESET_GPIO      GPIO_NUM_8

#define I2C_SCL_GPIO    GPIO_NUM_4
#define I2C_SDA_GPIO    GPIO_NUM_5

#define BUTTON_GPIO     GPIO_NUM_0
#define CHRG_GPIO       GPIO_NUM_1
#define RTC_WAKE_GPIO   GPIO_NUM_2

#define ADC_GPIO        GPIO_NUM_3
#define ADC_CTL_GPIO    GPIO_NUM_18

void gpio_prepare(void);
void gpio_prepare_deep_sleep(struct system_info *info);
void check_battery_state(struct system_info *info);

#endif

## Commit log

2024-01-12 Init repository
2024-12-09 V0.1
2024-12-22 Prepareing JAC
2024-12-22 Adjust battery icon coordinate
2024-12-22 fw: Reorganize code structure
2024-12-22 fw: version bump to 0.1.2
2024-12-22 fw: version bump to 0.1.3
2024-12-22 fw: version bump to 0.1.1
2024-12-22 fw: Add powersaving mode indicator
2024-12-22 fw: web file change
2024-12-22 fw: version bump to 0.1.4
2024-12-22 fw: EPD reset pin also need hold during update
2024-12-22 fw: add README.md
2024-12-22 hw: 4.2 inch screen variant
2025-01-05 fw: fix year add value
2025-01-05 fw: version bump to 0.1.5
2025-01-08 fw: unmmap res and unmount spiffs before OTA
2025-01-08 fw: version bump to 0.1.6
2025-01-08 fw: 4.2 inch screen variant
2025-01-23 fw: fix year add not read correctly
2025-02-23 fw: adjust soc and athd logic
2025-02-23 fw:version bump to 0.1.8
